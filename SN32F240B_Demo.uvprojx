# Keil uVision project SN32F240B_Demo.uvprojx, settings and files
target SN32F240B (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SN32F248BF SONiX
  pack: SONiX.SN32F2_DFP.1.3.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0xFFFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SN32F240B +hex
  AfterMake: HexConvert.exe SN32F240B "#H" 0
  c flags: Optim=1 v6Lang=1 v6LangP=1
  asm define: SN32F240B
  memory RVCT4: ROM 0x0 size 0xfffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group main
    ./: main.c GPIO.c SysTick.c
  group Utility
    ./Utility/: Utility.c
  group USB
    ./Usb/: usbram.c usbhw.c usbdesc.c usbuser.c usbepfunc.c
  group HID
    ./UsbHid/: hidram.c hiduser.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.1.0
